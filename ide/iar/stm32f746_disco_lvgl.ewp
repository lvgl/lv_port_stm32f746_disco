# IAR project stm32f746_disco_lvgl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32; STM32F7; STM32F746NGHx; STM32F746G_DISCO; DEBUG; STM32F746xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa089,Pe188
  ICCARM.CCIncludePath2: ../..; ../../CMSIS/Core; ../../CMSIS/Device; ../../HAL_Driver/Inc; ../../inc; ../../Utilities/STM32746G-Discovery
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f746_disco_lvgl.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32; STM32F7; STM32F746NGHx; STM32F746G_DISCO; DEBUG; STM32F746xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../..; ../../CMSIS/Core; ../../CMSIS/device; ../../HAL_Driver/Inc; ../../Utilities/STM32746G-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: stm32f746_disco_lvgl.hex
  group HAL_Driver/Src
    ../../HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group hal_stm_lvgl/tft
    ../../hal_stm_lvgl/tft/: tft.c
  group hal_stm_lvgl/touchpad
    ../../hal_stm_lvgl/touchpad/: touchpad.c
  group lvgl/demos
    ../../lvgl/demos/: lv_demos.c
  group lvgl/demos/benchmark
    ../../lvgl/demos/benchmark/: lv_demo_benchmark.c
  group lvgl/demos/benchmark/assets
    ../../lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
  group lvgl/demos/keypad_encoder
    ../../lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group lvgl/demos/music
    ../../lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
  group lvgl/demos/music/assets
    ../../lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c spectrum_1.h spectrum_2.h spectrum_3.h
  group lvgl/demos/render
    ../../lvgl/demos/render/: lv_demo_render.c
  group lvgl/demos/render/assets
    ../../lvgl/demos/render/assets/: img_render_arc_bg.c img_render_lvgl_logo_argb8888.c img_render_lvgl_logo_rgb565.c img_render_lvgl_logo_rgb888.c img_render_lvgl_logo_xrgb8888.c
  group lvgl/demos/stress
    ../../lvgl/demos/stress/: lv_demo_stress.c
  group lvgl/demos/vector_graphic
    ../../lvgl/demos/vector_graphic/: lv_demo_vector_graphic.c
  group lvgl/demos/vector_graphic/assets
    ../../lvgl/demos/vector_graphic/assets/: img_demo_vector_avatar.c
  group lvgl/demos/widgets
    ../../lvgl/demos/widgets/: lv_demo_widgets.c
  group lvgl/demos/widgets/assets
    ../../lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group lvgl/src
    ../../lvgl/src/: lv_conf_internal.h lv_init.c lvgl.h
  group lvgl/src/core
    ../../lvgl/src/core/: lv_global.h lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group lvgl/src/display
    ../../lvgl/src/display/: lv_display.c
  group lvgl/src/draw
    ../../lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group lvgl/src/draw/dma2d
    ../../lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
  group lvgl/src/draw/sw
    ../../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group lvgl/src/draw/sw/blend
    ../../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group lvgl/src/drivers
    ../../lvgl/src/drivers/: lv_drivers.h
  group lvgl/src/drivers/display/lcd
    ../../lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
  group lvgl/src/font
    ../../lvgl/src/font/: lv_binfont_loader.c lv_binfont_loader.h lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/src/indev
    ../../lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group lvgl/src/layouts
    ../../lvgl/src/layouts/: lv_layout.c
  group lvgl/src/layouts/flex
    ../../lvgl/src/layouts/flex/: lv_flex.c
  group lvgl/src/layouts/grid
    ../../lvgl/src/layouts/grid/: lv_grid.c
  group lvgl/src/libs/barcode
    ../../lvgl/src/libs/barcode/: code128.c lv_barcode.c
  group lvgl/src/libs/bin_decoder
    ../../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group lvgl/src/libs/bmp
    ../../lvgl/src/libs/bmp/: lv_bmp.c
  group lvgl/src/libs/ffmpeg
    ../../lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
  group lvgl/src/libs/freetype
    ../../lvgl/src/libs/freetype/: ftmodule.h ftoption.h lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
  group lvgl/src/libs/fsdrv
    ../../lvgl/src/libs/fsdrv/: lv_fs_arduino_esp_littlefs.cpp lv_fs_arduino_sd.cpp lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
  group lvgl/src/libs/gif
    ../../lvgl/src/libs/gif/: gifdec.c lv_gif.c
  group lvgl/src/libs/libjpeg_turbo
    ../../lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
  group lvgl/src/libs/libpng
    ../../lvgl/src/libs/libpng/: lv_libpng.c
  group lvgl/src/libs/lodepng
    ../../lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
  group lvgl/src/libs/qrcode
    ../../lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group lvgl/src/libs/tiny_ttf
    ../../lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group lvgl/src/libs/tjpgd
    ../../lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group lvgl/src/misc
    ../../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group lvgl/src/misc/cache
    ../../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
  group lvgl/src/misc/cache/class
    ../../lvgl/src/misc/cache/class/: lv_cache_class.h lv_cache_lru_ll.c lv_cache_lru_rb.c
  group lvgl/src/misc/cache/instance
    ../../lvgl/src/misc/cache/instance/: lv_cache_instance.h lv_image_cache.c lv_image_header_cache.c
  group lvgl/src/osal
    ../../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group lvgl/src/others/gridnav
    ../../lvgl/src/others/gridnav/: lv_gridnav.c
  group lvgl/src/others/observer
    ../../lvgl/src/others/observer/: lv_observer.c
  group lvgl/src/others/snapshot
    ../../lvgl/src/others/snapshot/: lv_snapshot.c
  group lvgl/src/others/sysmon
    ../../lvgl/src/others/sysmon/: lv_sysmon.c
  group lvgl/src/others/test
    ../../lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
  group lvgl/src/others/xml
    ../../lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
  group lvgl/src/others/xml/parsers
    ../../lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_event_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group lvgl/src/stdlib
    ../../lvgl/src/stdlib/: lv_mem.c lv_sprintf.h lv_string.h
  group lvgl/src/stdlib/builtin
    ../../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group lvgl/src/themes
    ../../lvgl/src/themes/: lv_theme.c
  group lvgl/src/themes/default
    ../../lvgl/src/themes/default/: lv_theme_default.c
  group lvgl/src/themes/mono
    ../../lvgl/src/themes/mono/: lv_theme_mono.c
  group lvgl/src/themes/simple
    ../../lvgl/src/themes/simple/: lv_theme_simple.c
  group lvgl/src/tick
    ../../lvgl/src/tick/: lv_tick.c
  group lvgl/src/widgets/animimage
    ../../lvgl/src/widgets/animimage/: lv_animimage.c
  group lvgl/src/widgets/arc
    ../../lvgl/src/widgets/arc/: lv_arc.c
  group lvgl/src/widgets/bar
    ../../lvgl/src/widgets/bar/: lv_bar.c
  group lvgl/src/widgets/button
    ../../lvgl/src/widgets/button/: lv_button.c
  group lvgl/src/widgets/buttonmatrix
    ../../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group lvgl/src/widgets/calendar
    ../../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group lvgl/src/widgets/canvas
    ../../lvgl/src/widgets/canvas/: lv_canvas.c
  group lvgl/src/widgets/chart
    ../../lvgl/src/widgets/chart/: lv_chart.c
  group lvgl/src/widgets/checkbox
    ../../lvgl/src/widgets/checkbox/: lv_checkbox.c
  group lvgl/src/widgets/dropdown
    ../../lvgl/src/widgets/dropdown/: lv_dropdown.c
  group lvgl/src/widgets/image
    ../../lvgl/src/widgets/image/: lv_image.c
  group lvgl/src/widgets/imagebutton
    ../../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group lvgl/src/widgets/keyboard
    ../../lvgl/src/widgets/keyboard/: lv_keyboard.c
  group lvgl/src/widgets/label
    ../../lvgl/src/widgets/label/: lv_label.c
  group lvgl/src/widgets/led
    ../../lvgl/src/widgets/led/: lv_led.c
  group lvgl/src/widgets/line
    ../../lvgl/src/widgets/line/: lv_line.c
  group lvgl/src/widgets/list
    ../../lvgl/src/widgets/list/: lv_list.c
  group lvgl/src/widgets/menu
    ../../lvgl/src/widgets/menu/: lv_menu.c
  group lvgl/src/widgets/msgbox
    ../../lvgl/src/widgets/msgbox/: lv_msgbox.c
  group lvgl/src/widgets/objx_templ
    ../../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group lvgl/src/widgets/roller
    ../../lvgl/src/widgets/roller/: lv_roller.c
  group lvgl/src/widgets/scale
    ../../lvgl/src/widgets/scale/: lv_scale.c
  group lvgl/src/widgets/slider
    ../../lvgl/src/widgets/slider/: lv_slider.c
  group lvgl/src/widgets/span
    ../../lvgl/src/widgets/span/: lv_span.c
  group lvgl/src/widgets/spinbox
    ../../lvgl/src/widgets/spinbox/: lv_spinbox.c
  group lvgl/src/widgets/spinner
    ../../lvgl/src/widgets/spinner/: lv_spinner.c
  group lvgl/src/widgets/switch
    ../../lvgl/src/widgets/switch/: lv_switch.c
  group lvgl/src/widgets/table
    ../../lvgl/src/widgets/table/: lv_table.c
  group lvgl/src/widgets/tabview
    ../../lvgl/src/widgets/tabview/: lv_tabview.c
  group lvgl/src/widgets/textarea
    ../../lvgl/src/widgets/textarea/: lv_textarea.c
  group lvgl/src/widgets/tileview
    ../../lvgl/src/widgets/tileview/: lv_tileview.c
  group lvgl/src/widgets/win
    ../../lvgl/src/widgets/win/: lv_win.c
  group src
    ../../src/: adc.c crc.c dcmi.c dma2d.c eth.c fmc.c gpio.c i2c.c ltdc.c main.c quadspi.c rtc.c sai.c sdmmc.c spdifrx.c spi.c stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c tim.c usart.c usb_otg.c
  group startup
    ./: startup_stm32f746xx.s
  group Utilities/Components/ft5336
    ../../Utilities/Components/ft5336/: ft5336.c
  group Utilities/Components/rk043fn48h
    ../../Utilities/Components/rk043fn48h/: rk043fn48h.h
  group Utilities/Fonts
    ../../Utilities/Fonts/: font12.c font16.c font20.c font24.c font8.c fonts.h
  group Utilities/STM32746G-Discovery
    ../../Utilities/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
