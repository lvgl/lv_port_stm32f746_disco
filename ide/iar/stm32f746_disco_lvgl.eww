<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm32f746_disco_lvgl.ewp</path>
    </project>
    <batchBuild />
</workspace>
